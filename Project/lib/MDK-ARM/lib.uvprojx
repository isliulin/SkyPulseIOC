# Keil uVision project lib.uvprojx, settings and files
target libSkyPulse (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F205VG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(120000000) ELITTLE
  output: libSkyPulse (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_USB_OTG_FS,__PFM6__,HSE_VALUE=25000000
  c include: ..\inc;..\inc\app;..\inc\usbd_msc;..\inc\usbd_cdc;..\inc\usbh_msc;..\src\wifi;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\Libraries\STM32_USB_Host_Library\Class\msc\inc;..\..\..\Libraries\STM32_USB_Device_Library\Class\msc\inc;..\..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc;..\..\..\Utilities\FatFs_R0.10b\src;..\..\..\Utilities\STM32F4-Discovery;..\inc\tcp;..\..\..\Utilities\lwip_v1.3.2\src\include;..\..\..\Utilities\lwip_v1.3.2\src\include\ipv4;..\..\..\Utilities\lwip_v1.3.2\src\include\lwip;..\..\..\Utilities\lwip_v1.3.2\src\include\netif;..\..\..\Utilities\lwip_v1.3.2\port\STM32F4x7;..\..\..\Utilities\lwip_v1.3.2\port\STM32F4x7\Standalone;..\..\..\Utilities\MP3
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../src/app/: main.c app.c appmisc.c com.c
  group Setup
    ../src/app/: nvic.c usart.c
  group Misc
    ../src/app/: io.c led.c retarget.c
    ../src/usb/: stm32fxxx_it.c
  group USBD User
    ../src/usb/: usbd_storage_msd.c usbd_usr.c usb_bsp.c
  group USBH User
    ../src/usb/: usbh_msc_usr.c
  group USB Driver
    ../../../Libraries/STM32_USB_OTG_Driver/src/: usb_dcd_int.c usb_core.c usb_dcd.c usb_hcd_int.c usb_hcd.c
  group USB Device
    ../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_req.c usbd_core.c usbd_ioreq.c
  group USB Host
    ../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_stdreq.c usbh_core.c usbh_hcs.c usbh_ioreq.c
  group USBD MSC
    ../../../Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
    ../src/usb/: usbd_msc_desc.c
  group USBD CDC
    ../../../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    ../src/usb/: usbd_cdc_vcp.c usbd_vcp_desc.c
  group USBH MSC
    ../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group FatFs
    ../../../Utilities/FatFs_R0.10b/src/: ff.c
    ../../../Utilities/FatFs_R0.10b/src/option/: ccsbcs.c
  group STM32F2xx
    ../src/: system_stm32f2xx.c startup_stm32f2xx.s
  group STM32F2xx_StdPeriph_Driver
    ../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_syscfg.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_usart.c stm32f2xx_tim.c stm32f2xx_sdio.c misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_iwdg.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_wwdg.c
  group Doc
    ../src/: readme.txt
  group TCP
    ../src/tcp/: netconf.c server.c stm32f4x7_eth_bsp.c apptcp.c
    ../../../Utilities/STM32F4-Discovery/: stm32f4x7_eth.c
  group FTP
    ../src/tcp/: ftp.c vfs.c
  group LCD
    ../../../Utilities/STM32F4-Discovery/: stm32f4_discovery_lcd.c STMPE811QTR.c
  group LWIP
    ../../../Utilities/lwip_v1.3.2/port/STM32F4x7/Standalone/: ethernetif.c
    ../../../Utilities/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbios.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../Utilities/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../../Utilities/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../Utilities/lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
  group MP3
    ../../../Utilities/MP3/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3dec.c mp3tabs.c polyphase.c scalfact.c stproc.c subband.c trigtabs.c uv_mp3.s
target libDiscovery (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F207VG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: as above
  output: libDiscovery +hex (library)
  c flags: Optim=4 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_USB_OTG_FS,__DISCO__,HSE_VALUE=8000000
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
