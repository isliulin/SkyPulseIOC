# Keil uVision project SkyPulse.uvprojx, settings and files
target IOC_V2 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SkyPulseIOC2 +hex
  AfterMake: pproc.bat
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, ARM_MATH_CM3,__IOC_V2__
  c misc: --exceptions
  c include: .\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Utilities\STM32F4-Discovery;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Utilities\FatFs_R0.10b\src;..\lib\inc
  memory RVCT4: ROM 0x8008000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ./Source/: lm.cpp pump.cpp fan.cpp spray.cpp ws2812.cpp isr.cpp fit.cpp
  group Peripherals
    ./Source/: adc.cpp tim.cpp can.cpp gpio.cpp dac.cpp term.cpp
  group System
    ../lib/MDK-ARM/output/: libSkyPulseV1.lib libSkyPulseV2.lib libDiscovery.lib
  group Simulator
    ./Source/: simulator.cpp lcd.cpp
  group Doc
    ./Include/: Doc.txt
target IOC_V1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: as above
  output: SkyPulseIOC1 +hex
  AfterMake: pproc.bat
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, ARM_MATH_CM3,__IOC_V1__
  c misc: --exceptions
  c include: as above
  memory RVCT4: ROM 0x8008000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target IOC_V0 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: as above
  output: SkyPulseIOC0 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, ARM_MATH_CM3,__IOC_V0__
  c misc: --exceptions
  c include: .\Include;..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\Utilities\STM32F4-Discovery;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\Utilities\FatFs_R0.10b\src;..\lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target IOC_Discovery (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: as above
  output: SkyPulseDiscovery +hex
  AfterMake: pproc.bat
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,__DISCO__,__IOC_V2__
  c misc: --exceptions
  c include: ..\lib\inc;.\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Utilities\STM32F4-Discovery;..\..\Utilities\FatFs_R0.10b\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
